.subckt npn13G2 c b e bn
.ends
